# Keil uVision project DRGB_01_ALT_V26.uvproj, settings and files
target DRGB_01 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: DRGB_01_ALT_V26+ +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c
